# Keil uVision project Project.uvproj, settings and files
target stm32f1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\STM32F10x_StdPeriph_Template;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\Application;..\Config;..\Resource
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group LIB_M3
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c
  group LIB_M4
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_pwr.c
  group STD
    ../STM32F10x_StdPeriph_Template/: stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
    ../STM32F4xx_StdPeriph_Templates/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
  group APP
    ../Application/: _common.c cmdParse.c Cascade.c modbus.c main.c
  group RES
    ../Resource/: UniversalSCom.c
  group CFG
    ../Config/: iox.c 74HC595.c uart2.c uartx.c dmax.c uart1.c uart4.c tim8.c tim4.c
target stm32f4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\CMSIS\Include;..\STM32F4xx_StdPeriph_Templates;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Application;..\Config;..\Resource
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
