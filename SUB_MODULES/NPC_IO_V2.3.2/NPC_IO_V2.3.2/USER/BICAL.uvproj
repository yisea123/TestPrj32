# Keil uVision project BICAL.uvproj, settings and files
target bical (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BICAL +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\TIMER;..\HARDWARE\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\CORE;..\HARDWARE\EXTI;..\SYSTEM\usart;..\HARDWARE\AD;..\HARDWARE\DA;..\HARDWARE\LED;..\HARDWARE\CDV_define;..\STM32F10x_FWLib\inc;..\HARDWARE\IO;..\HARDWARE\Modbus
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group hardware
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/USER/: user.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/AD/: adc.c
    ../HARDWARE/DA/: DAC7512.c dac.c
    ../HARDWARE/CDV_define/: cdv_define.c
    ../HARDWARE/IO/: IO.c
    ../HARDWARE/Modbus/: modbus.c
  group system
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group core
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group fwlib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c
