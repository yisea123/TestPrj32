# Keil uVision project NPC.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F417IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NPC +hex
  AfterMake: $KARM\ARMCC\bin\fromelf.exe --bin -o Obj\NPC.bin Obj\NPC.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=550,177,1
  c include: ..\STM32F4xx_StdPeriph_Templates;..\User;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\UCOSIII\Micrium\Software\uC-CPU;..\UCOSIII\Micrium\Software\uC-CPU\ARM-Cortex-M4\RealView;..\UCOSIII\Micrium\Software\uC-LIB;..\UCOSIII\Micrium\Software\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSIII\Micrium\Software\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\UCOSIII\Micrium\Software\uCOS-III\Source;..\UCOSIII\Micrium\Software\STM32F417;..\ThirdPart;..\Resource;..\Resource\ProportionalValve;..\Config;..\Libraries\STM32F4x7_ETH_Driver\inc;..\lwip-1.4.1\src\include\ipv4;..\lwip-1.4.1\src\include;..\lwip-1.4.1\src\include\netif;..\lwip-1.4.1\port\STM32F4x7;..\lwip-1.4.1\port\STM32F4x7\UCOSIII;..\lwip-1.4.1\prj;..\lwip-1.4.1\src\include\lwip;..\lwip-1.4.1\prj\tcp_server;..\lwip-1.4.1\prj\web_server_demo;..\lwip-1.4.1\prj\udp
  memory RVCT4: ROM 0x8020000 size 0xe0000
  memory RVCT6: RAM 0x68000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c cdv_config.c cdv_define.c offline.c basic_resource.c FPGA_spi.c FPGA.c mainUart.c log.c cdv_array.c newScript.c modbus.c serial_resource.c worker.c cmdParse.c Cascade.c CentralizedControl.c workerDebug.c
    ../lwip-1.4.1/prj/tcp_server/: tcp_server.c
    ../lwip-1.4.1/prj/udp/: udpmain.c
  group Resource
    ../Resource/: SysMng.c Logic.c Moto.c Tray.c IO.c Var.c Msg.c Time.c MotoParmTrans.c adc.c dac.c DAC7512.c PH.c CSBCtrl.c UniversalSCom.c Alarm.c led.c VarExp.c PID.c memmng.c FlashBak.c
    ../Resource/ProportionalValve/: ProportionalValve.c
  group Config
    ../Config/: uart1.c uart2.c uart3.c uart4.c uart5.c uart6.c spix.c exti.c spi2.c spi3.c uartx.c dmax.c lan8720.c sram.c pvd.c lowPower.c extiPowerOff.c tim8.c
  group STM32F4xx_StdPeriph_Templates
    ../STM32F4xx_StdPeriph_Templates/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
  group Libraries
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_dac.c stm32f4xx_adc.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_fsmc.c stm32f4xx_flash.c
    ../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group UCOSIII
    ../UCOSIII/Micrium/Software/STM32F417/: bsp.c os_app_hooks.c
    ../UCOSIII/Micrium/Software/uC-CPU/: cpu_core.c
    ../UCOSIII/Micrium/Software/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
    ../UCOSIII/Micrium/Software/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/Micrium/Software/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../UCOSIII/Micrium/Software/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_c.c os_cpu_a.asm
    ../UCOSIII/Micrium/Software/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group ThirdPart
    ../ThirdPart/: delay.c usart.c flash.c rtc.c sysdef.c malloc.c flash_if.c
  group ReadMe
    ../txt/: Update.txt readme.txt
  group LWIP
    ../lwip-1.4.1/port/STM32F4x7/UCOSIII/: ethernetif.c sys_arch.c
    ../lwip-1.4.1/src/netif/: etharp.c
    ../lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lwip-1.4.1/prj/: lwip_comm.c
    ../lwip-1.4.1/prj/web_server_demo/: fs.c httpd.c httpd_cgi_ssi.c
